FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://debug-uart.cfg"
SRC_URI += "file://debug-uart.cfg"
